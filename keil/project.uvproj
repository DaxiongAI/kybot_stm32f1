# Keil uVision project project.uvproj, settings and files
target kybot (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kybot +hex
  AfterMake: fromelf --bin !L --output kybot.bin
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\STM32F10x_StdPeriph_Driver\inc;..\inc\app;..\inc\bsp;...\lib\CMSIS\CM3\CoreSupport;..\inc\base;..\inc;..\inc\at
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32_StdPeriph
    ../lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dma.c misc.c stm32f10x_i2c.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group app
    ../src/app/: buffer.c delay.c halfsecond.c main.c param.c workdata.c datetime.c imu.c event.c allan.c kalman.c controller.lib encrypt.lib feedback.lib log.lib protocol.lib shell.lib
  group bsp
    ../src/bsp/: adc.c buzzer.c eeprom.c encoder.c key.c led.c motor.c l3g4200.c stm32f10x_it.c tim.c usart.c i2c1_hw.c adxl345.c
  group base
    ../src/base/: file_id.c
  group at
    ../src/at/: at.lib
